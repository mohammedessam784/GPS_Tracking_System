# Keil uVision project GPS_Tracking_System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GPS_Tracking_Milestone_1st
  c flags: Optim=1
  c include: .\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./Drivers/APP/: main.c system_init.c main_app.c
  group HAL
    ./Drivers/HAL/LED/: LED.c
    ./Drivers/HAL/BUTTON/: BUTTON.c
    ./Drivers/HAL/LCD/: LCD.c
    ./Drivers/HAL/GPS/: GPS.c
  group MCAL
    ./Drivers/MCAL/GPIO/: GPIO.c
    ./Drivers/MCAL/UART/: UART.c
    ./Drivers/MCAL/SYSTICK/: SYSTICK.c
    ./Drivers/MCAL/EEPROM/: EEPROM.c
    ./Drivers/MCAL/ADC/: ADC.c
  group Source Group 1
    ./: startup_TM4C123.s
